Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2025-05-05T10:39:37
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190327_2315(x64) - Exporter 20.0.0.377 - IU alternativa 20.0.0.377
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon May 05 10:39:37 2025 * Host: MichellyManno * Database: C:\Users\MICHEL~1\AppData\Local\Temp\5be6b166-0bf3-49b2-bca4-735c6575de5f\8fdacc95-5df5-40ac-aa6a-cd33e6d9b773\ifc * Database version: 5507 * Database creation date: Mon May 05 10:39:34 2025 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon May 05 10:39:35 2025 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon May 05 10:39:35 2025 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome do projeto; Phase: Status do projeto

# IfcSite, Default
RefLatitude: -15, -52, 0, -120620; RefLongitude: -47, -55, 0, -114440; RefElevation: 0 mm
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuildingStorey: Nível:Cabeça de 8 mm, Nível 1
LongName: Nível 1; Elevation: 0 mm
Restrições(Type) - Base da elevação: Ponto base do projeto
Outros(Type) - Categoria: Níveis; Nome da família: Nível
Cotas - Cálculo da altura: 0 mm
Dados de identidade - Andar da construção: yes; Estrutural: no; Nome: Nível 1
Outros - Categoria: Níveis; Família: Nível: Cabeça de 8 mm; Família e tipo: Nível: Cabeça de 8 mm; ID de tipo: Nível: Cabeça de 8 mm; Tipo: Nível: Cabeça de 8 mm
Restrições - Elevação: 0 mm
Dados de identidade(Type) - Nome do tipo: Cabeça de 8 mm
Gráficos(Type) - Cor: 0; Espessura da linha: 1; Padrão de linha: Centro (1); Símbolo: M_Cabeça do nível - Círculo: M_Cabeça do nível - Círculo; Símbolo no final 1 padrão: no; Símbolo no final 2 padrão: yes

# IfcDistributionPort, Port_328371
Description: Flow; FlowDirection: SOURCEANDSINK

# IfcFlowTerminal: 6802, Downlight_Powerus_6802_Nordecor_IFC:6802:328371
In: Nível 1
Type - Material: LED, Metal - Alumínio - Branco, Plástico - Policarbonato - Translúcido
Type - Cotas - Altura da luminária: 70 mm; Comprimento da luminária: 58 mm; Largura da luminária: 36 mm
Type - Dados - Data da atualização: 05/05/2024; Versão: 1
Type - Dados de identidade - Contato do desenvolvedor: contato@checkbim.com.br; Contato do fabricante: comercial@nordecor.com.br; Descrição: Downlight de sobrepor com acabamento branco, 2 focos, LED 4W, 4000K 35º; Desenvolvedor: Check BIM; Fabricante: Nordecor; Fixação: Parafusos; Garantia: 2 Anos; Grau de proteção: IP20; Localização: Camboriú-SC / Brasil; Modelo: 6802; Nome do tipo: 6802; Número OmniClass: 23.80.70.11.14.14; Tipo de imagem: Imagem raster: 6802.png; Título OmniClass: Uplights; URL: https://nordecor.com.br; URL do desenvolvedor: https://checkbim.com.br/; URL do produto: https://nordecor.com.br/produto/downlight-led-de-sobrepor-powerus-2-leds-35-4w-4-000k-irc90/
Type - Elétrico - Comentários de voltagem: 85-265V; Fator de potência - Luminária: 0.5; Lâmpada: LED
Type - Elétrico - Cargas - Carga aparente - Luminária: 0 W
Type - Engenharia elétrica - Voltagem - Luminária: 0 V
Type - Estrutural - Peso: 0.114
Type - Fotométricos - Fluxo luminoso: 346 lm; Grau de abertura: 35 deg; IRC (R9): >70; IRC (RA): >90; Potência: 4 W; SDMC: <3; Temperatura de cor: 4000 K; UGR: <13
Type - Gráficos - Simbologia: Imagem raster: 6802 2D.png
Type - Materiais e acabamentos - Difusor: Plástico - Policarbonato - Translúcido; Luminária: Metal - Alumínio - Branco
Type - Outros - Categoria: Luminárias; Branco: yes; Nome da família: Downlight_Powerus_6802_Nordecor_IFC
Type - Restrições - Elevação-padrão: 1219.2 mm
Type - Visibilidade - 2D: yes
Pset_DistributionFlowElementCommon - Reference: 6802; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Nordecor
Cotas - Área: 0.00925236 m2; Volume: 0.000138315 m3
Dados de identidade - Marca: 1
Elétrico - Circuitos - Dados elétricos: 0 V/1-0 VA
Elétrico - Iluminação - Calcular coeficiente de utilização: no
Fase - Fase criada: Construção nova
Outros - Família: Downlight_Powerus_6802_Nordecor_IFC: 6802; Família e tipo: Downlight_Powerus_6802_Nordecor_IFC: 6802; ID de tipo: Downlight_Powerus_6802_Nordecor_IFC: 6802; Tipo: Downlight_Powerus_6802_Nordecor_IFC: 6802
Restrições - Elevação do nível: 0 mm; Hospedeiro: Nível : Nível 1; Nível: Nível: Nível 1; Nível de tabela: Nível: Nível 1
